# Keil uVision project AudioCodec.uvproj, settings and files
target AudioCodec (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: AudioCodec +hex
  AfterMake: fromelf.exe --bin -o "#L.bin" "#L"
  c flags: Optim=1 oTime=1
  c define: FUNC_DEBUG_EN FUNC_APP_DEBUG_EN
  c include: ..\..\Libraries\audio\inc;..\..\Libraries\driver\inc;.\codec;.\user
  scatter file: .\AudioCodec.sct
  link misc: --keep *.o(.driver*.isr) --keep *.o(CACHE.4KBMEM)
  group main
    ./: startup.c retarget.c main.c
    ./codec/: codec_effects.c codec_mixer.c mcu_circular_buf.c communication.c
    ./user/: user_effects_param.c
  group libs
    ../../Libraries/driver/: driver.lib
    ../../Libraries/audio/: drc.lib echo.lib expander.lib pitch_shifter.lib blue_aec.lib
