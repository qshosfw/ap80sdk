# Keil uVision project PwcExample.uvproj, settings and files
target PwcExample (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: PwcExample
  AfterMake: fromelf.exe --bin -o "#L.bin" "#L"
  c flags: Optim=1 OneElfS=1
  c define: FUNC_DEBUG_EN FUNC_APP_DEBUG_EN
  c include: ..\..\Libraries\audio\inc;..\..\Libraries\driver\inc
  scatter file: .\PwcExample.sct
  link misc: --keep *.o(.driver*.isr) --keep *.o(CACHE.4KBMEM)
  group main
    ./: startup.c PwcExample.c retarget.c
  group libs
    ../../Libraries/driver/: driver.lib
