# Keil uVision project BuartExample.uvproj, settings and files
target BuartExample (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: BuartExample
  c flags: Optim=1 OneElfS=1
  c include: ..\..\Libraries\driver\inc;..\..\Libraries\fs\inc;..\..\Libraries\os\inc
  scatter file: .\BuartExample.sct
  link misc: --keep *.o(.mach*.init)  --keep *.o(.shell*.cmd)  --keep *.o(.notify*.init)  --keep *.o(.sched.stub*) --keep *.o(.driver*.isr) --keep *.o(CACHE.4KBMEM)
--diag_suppress=L6314W,L6319W
  group main
    ./: BuartExample.c Retarget.c startup.c
  group libs
    ../../Libraries/driver/: driver.lib
