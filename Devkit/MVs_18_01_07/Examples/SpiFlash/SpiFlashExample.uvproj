# Keil uVision project SpiFlashExample.uvproj, settings and files
target SpiFlash (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: SpiFlashExample
  c flags: Optim=1 OneElfS=1
  c include: ..\..\Libraries\driver\inc
  scatter file: .\MVs18.sct
  link misc: --keep *.o(.mach*.init)  --keep *.o(.shell*.cmd)  --keep *.o(.notify*.init)  --keep *.o(.sched.stub*) --keep *.o(.driver*.isr) --keep *.o(CACHE.4KBMEM) --diag_suppress=L6314W,L6319W
  group main
    ./: SpiFlashExample.c
  group extern
    ./: retarget.c startup.c
    ../../Libraries/driver/: driver.lib
