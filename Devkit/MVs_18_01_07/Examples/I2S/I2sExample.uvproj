# Keil uVision project I2sExample.uvproj, settings and files
target I2sExample (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: I2sExample +hex
  AfterMake: fromelf.exe --bin -o "#L.bin" "#L"
  c flags: Optim=1 OneElfS=1
  c define: FUNC_DEBUG_EN FUNC_APP_DEBUG_EN
  c include: ..\..\Libraries\audio\inc;..\..\Libraries\driver\inc
  scatter file: .\I2sExample.sct
  link misc: --keep *.o(.driver*.isr) --keep *.o(CACHE.4KBMEM)
  group main
    ./: startup.c I2sExample.c retarget.c
  group libs
    ../../Libraries/driver/: driver.lib
