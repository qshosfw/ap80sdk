# Keil uVision project SpiStreamPlayer.uvproj, settings and files
target Master (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: SpiStreamPlayer_Master
  AfterMake: cmd /C del /Q *.o *.d *.crf  *.dep *.lnp
  c flags: Optim=1 OneElfS=1
  c define: INDEPEND_FREERTOS
  c misc: --diag_suppress=1488
  c include: ..\..\Libraries\audio\inc;..\..\Libraries\driver\inc;..\..\Libraries\fs\inc
  scatter file: .\SpiStreamPlayer.sct
  link misc: --keep *.o(.mach*.init)  --keep *.o(.shell*.cmd)  --keep *.o(.notify*.init)  --keep *.o(.sched.stub*) --keep *.o(.driver*.isr) --keep *.o(CACHE.4KBMEM) --diag_suppress=L6314W,L6319W
  group fs
    ./: presearch.c diskio.c filesort.c partition.c
  group main
    ./: crc.c ssap_master.c ssap_slaver.c startup.c string_convert.c retarget.c
  group libs
    ../../Libraries/audio/: audio_decoder.lib audio_utility.lib
    ../../Libraries/fs/: fs.lib
    ../../Libraries/driver/: driver.lib
    ../../Libraries/character_encoding/: character_encoding.lib
target Slaver (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: SpiStreamPlayer_Slaver
  AfterMake: cmd /C del /Q *.o *.d *.crf  *.dep *.lnp
  c flags: Optim=1 OneElfS=1
  c define: INDEPEND_FREERTOS
  c misc: --diag_suppress=1488
  c include: as above
  scatter file: .\SpiStreamPlayer.sct
  link misc: --keep *.o(.mach*.init)  --keep *.o(.shell*.cmd)  --keep *.o(.notify*.init)  --keep *.o(.sched.stub*) --keep *.o(.driver*.isr) --keep *.o(CACHE.4KBMEM)  --diag_suppress=L6314W,L6319W
