# Keil uVision project SleepExample.uvproj, settings and files
target SleepExample (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: SleepExample
  AfterMake: fromelf.exe --bin -o "#L.bin" "#L"
  c flags: Optim=1 OneElfS=1
  c define: FUNC_DEBUG_EN FUNC_APP_DEBUG_EN
  c include: ..\..\Libraries\driver\inc
  scatter file: .\SleepExample.sct
  link misc: --keep *.o(.driver*.isr) --keep *.o(CACHE.4KBMEM)
  group main
    ./: startup.c SleepExample.c retarget.c
  group libs
    ../../Libraries/driver/: driver.lib
