# Keil uVision project SarAdc.uvproj, settings and files
target SarAdc (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: SarAdc
  c flags: Optim=1 OneElfS=1
  c include: ..\..\Libraries\driver\inc
  scatter file: .\SarAdcExample.sct
  link misc: --diag_suppress=L6314W,L6319W
  group example
    ./: SarAdcExample.c
  group config
    ./: startup.c retarget.c
    ../../Libraries/driver/: driver.lib
