# Keil uVision project LCDSEG.uvproj, settings and files
target lcdseg (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: lcdseg
  AfterMake: fromelf.exe --bin -o "#L.bin" "#L"
  c flags: Optim=1 OneElfS=1
  c include: ..\..\Libraries\driver\inc
  scatter file: .\MVs18.sct
  link misc: --keep *.o(.mach*.init)  --keep *.o(.shell*.cmd)  --keep *.o(.notify*.init)  --keep *.o(.sched.stub*) --keep *.o(.driver*.isr) --keep *.o(CACHE.4KBMEM) --diag_suppress=L6314W,L6319W
  group main
    ./: lcdseg_example.c
  group extern
    ../../Libraries/driver/: driver.lib
    ./: startup.c retarget.c
