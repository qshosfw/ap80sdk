# Keil uVision project FS.uvproj, settings and files
target FS (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: MVs18
  c flags: Optim=1 OneElfS=1
  c define: INDEPEND_FREERTOS
  c include: ..\..\Libraries\driver\inc;..\..\Libraries\fs\inc;..\..\..\LibrariesSrc\CharacterEncoding
  scatter file: .\FS.sct
  link misc: --keep *.o(.mach*.init)  --keep *.o(.shell*.cmd)  --keep *.o(.notify*.init)  --keep *.o(.sched.stub*) --keep *.o(.driver*.isr) --keep *.o(CACHE.4KBMEM)
--diag_suppress=L6314W,L6319W
  group main
    ./: fs.c startup.c retarget.c
  group libs
    ../../Libraries/driver/: driver.lib
    ../../Libraries/fs/: fs.lib
    ../../Libraries/character_encoding/: character_encoding.lib
  group fs
    ./: presearch.c diskio.c filesort.c partition.c
