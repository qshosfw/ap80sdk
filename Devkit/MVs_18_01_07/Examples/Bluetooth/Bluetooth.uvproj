# Keil uVision project Bluetooth.uvproj, settings and files
target Bluetooth (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: Blutooth
  AfterMake: cmd /C del /Q *.o *.d *.crf  *.dep *.lnp
  c flags: Optim=1 OneElfS=1
  c define: FUNC_DEBUG_EN
  c include: ..\..\Libraries\audio\inc;..\..\Libraries\bluetooth\inc;..\..\Libraries\driver\inc;..\..\Libraries\fs\inc;..\..\Libraries\os\inc
  scatter file: .\Bluetooth.sct
  link misc: --keep *.o(.mach*.init)  --keep *.o(.shell*.cmd)  --keep *.o(.notify*.init)  --keep *.o(.sched.stub*) --keep *.o(.driver*.isr) --keep *.o(CACHE.4KBMEM) --diag_suppress=L6314W,L6319W
  group libs
    ../../Libraries/driver/: driver.lib
    ./: bt-no-os.lib
    ../../Libraries/audio/: audio_utility.lib audio_decoder.lib audio_bluetooth.lib
  group main
    ./: main.c startup.c task_bt.c bte2prom.c pcm_sync.c spp_app_proc.c obex_spp_proc.c bt_device_cfg.c bt_app_ui_callback.c bt_play_internal_api.c retarget.c
