# Keil uVision project SdramExample.uvproj, settings and files
target SdramExample (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: SdramExample
  c flags: Optim=1 OneElfS=1
  c include: ..\..\Libraries\driver\inc;..\..\Libraries\os\inc
  scatter file: .\SdramExample.sct
  link misc: --diag_suppress=L6314W,L6319W
  group main
    ./: sdram_example.c retarget.c startup.c
  group libs
    ../../Libraries/driver/: driver.lib
