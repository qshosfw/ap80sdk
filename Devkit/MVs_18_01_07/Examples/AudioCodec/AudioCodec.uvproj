# Keil uVision project AudioCodec.uvproj, settings and files
target AudioDecoder (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: AudioCodec_AudioDecoder
  c flags: Optim=1 OneElfS=1
  c define: USE_HW_DECODER INDEPEND_FREERTOS
  c misc: --diag_suppress=1488
  c include: ..\..\Libraries\audio\inc;..\..\Libraries\driver\inc;..\..\Libraries\fs\inc;..\..\Libraries\os\inc
  scatter file: .\AudioCodec.sct
  link misc: --keep *.o(.mach*.init)  --keep *.o(.shell*.cmd)  --keep *.o(.notify*.init)  --keep *.o(.sched.stub*) --keep *.o(.driver*.isr) --keep *.o(CACHE.4KBMEM) --diag_suppress=6314,6319
  group fs
    ./: presearch.c filesort.c partition.c diskio.c
  group main
    ./: startup.c eq_params.c enc_out_buff.c string_convert.c mp3_encoder_test.c audio_decoders_test.c audio_encoders_test.c audio_encoders_test_without_os.c retarget.c
  group libs
    ../../Libraries/fs/: fs.lib
    ../../Libraries/driver/: driver.lib
    ../../Libraries/os/: freertos.lib
    ../../Libraries/audio/: libmp3enc.lib audio_utility.lib audio_decoder.lib audio_encoder.lib
    ../../Libraries/character_encoding/: character_encoding.lib
target AudioEncoder-OS (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: AudioCodec_AudioEncoder-OS
  c flags: Optim=1 OneElfS=1
  c define: USE_HW_DECODER INDEPEND_FREERTOS
  c misc: --diag_suppress=1488
  c include: ..\..\Libraries\audio\inc;..\..\Libraries\bluetooth\inc;..\..\Libraries\driver\inc;..\..\Libraries\fs\inc;..\..\Libraries\os\inc
  scatter file: .\AudioCodec.sct
  link misc: as above
target AudioEncoder+OS (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: AudioCodec_AudioEncoder+OS
  c flags: Optim=1 OneElfS=1
  c define: USE_HW_DECODER FREERTOS_VERSION
  c misc: --diag_suppress=1488
  c include: as above
  scatter file: .\AudioCodec.sct
  link misc: as above
target MP3Encoder+OS (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: AudioCodec_MP3Encoder+OS
  AfterMake: cmd /C del /Q output\*.o output\*.d output\*.crf  output\*.dep output\*.lnp
  c flags: Optim=1 OneElfS=1
  c define: USE_HW_DECODER FREERTOS_VERSION
  c misc: --diag_suppress=1488
  c include: as above
  scatter file: .\AudioCodec.sct
  link misc: as above
