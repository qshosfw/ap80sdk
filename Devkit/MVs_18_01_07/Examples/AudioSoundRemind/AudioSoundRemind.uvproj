# Keil uVision project AudioSoundRemind.uvproj, settings and files
target AudioSoundRemind (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: Audio_SoundRemind
  c flags: Optim=1 OneElfS=1
  c define: USE_HW_DECODER INDEPEND_FREERTOS
  c misc: --diag_suppress=1488
  c include: ..\..\Libraries\audio\inc;..\..\Libraries\bluetooth\inc;..\..\Libraries\driver\inc;..\..\Libraries\fs\inc;..\..\Libraries\os\inc
  scatter file: .\AudioSoundRemind.sct
  link misc: --keep *.o(.mach*.init)  --keep *.o(.shell*.cmd)  --keep *.o(.notify*.init)  --keep *.o(.sched.stub*) --keep *.o(.driver*.isr) --keep *.o(CACHE.4KBMEM) --diag_suppress=6314,6319
  group fs
    ./: presearch.c diskio.c filesort.c partition.c
  group mian
    ./: startup.c retarget.c main.c sound_remind.c upgrade_detect.c
  group lib
    ../../Libraries/audio/: audio_decoder.lib audio_utility.lib
    ../../Libraries/fs/: fs.lib
    ../../Libraries/character_encoding/: character_encoding.lib
    ../../Libraries/driver/: driver.lib
