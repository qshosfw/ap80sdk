# Keil uVision project TouchkeyExample.uvproj, settings and files
target TouchKey (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: TouchkeyExample
  c flags: Optim=1 OneElfS=1
  c include: ..\..\Libraries\driver\inc
  scatter file: .\TouchKeyExample.sct
  link misc: --diag_suppress=L6314W,L6319W
  group config
    ./: startup.c retarget.c
    ../../Libraries/driver/: driver.lib
  group example
    ./: TouchkeyExample.c
