# Keil uVision project SpiBasic.uvproj, settings and files
target Master (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: SpiBasic_Master
  AfterMake: cmd /C del /Q *.o *.d *.crf  *.dep *.lnp
  c flags: Optim=1 OneElfS=1
  c define: INDEPEND_FREERTOS
  c misc: --diag_suppress=1488
  c include: ..\..\Libraries\audio\inc;..\..\Libraries\driver\inc;..\..\Libraries\fs\inc;..\..\Libraries\os\inc
  scatter file: .\SpiBasic.sct
  link misc: --keep *.o(.mach*.init)  --keep *.o(.shell*.cmd)  --keep *.o(.notify*.init)  --keep *.o(.sched.stub*) --keep *.o(.driver*.isr) --keep *.o(CACHE.4KBMEM) --diag_suppress=L6314W,L6319W
  group main
    ./: crc.c startup.c master.c slaver.c retarget.c
  group libs
    ../../Libraries/driver/: driver.lib
target Slaver (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: SpiBasic_Slaver
  AfterMake: cmd /C del /Q *.o *.d *.crf  *.dep *.lnp
  c flags: Optim=1 OneElfS=1
  c define: INDEPEND_FREERTOS
  c misc: --diag_suppress=1488
  c include: as above
  scatter file: .\SpiBasic.sct
  link misc: --keep *.o(.mach*.init)  --keep *.o(.shell*.cmd)  --keep *.o(.notify*.init)  --keep *.o(.sched.stub*) --keep *.o(.driver*.isr) --keep *.o(CACHE.4KBMEM)  --diag_suppress=L6314W,L6319W
