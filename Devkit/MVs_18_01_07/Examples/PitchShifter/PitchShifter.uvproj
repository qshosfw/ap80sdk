# Keil uVision project PitchShifter.uvproj, settings and files
target Demo (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: PitchShifterDemo
  c flags: Optim=1 OneElfS=1
  c define: USE_HW_DECODER INDEPEND_FREERTOS
  c misc: --diag_suppress=1488
  c include: ..\..\Libraries\audio\inc;..\..\Libraries\driver\inc;..\..\Libraries\fs\inc
  scatter file: .\PitchShifter.sct
  link misc: --keep *.o(.mach*.init)  --keep *.o(.shell*.cmd)  --keep *.o(.notify*.init)  --keep *.o(.sched.stub*) --keep *.o(.driver*.isr) --keep *.o(CACHE.4KBMEM) --diag_suppress=6314,6319
  group fs
    ./: presearch.c diskio.c filesort.c partition.c
  group main
    ./: startup.c string_convert.c pitch_shifter_test.c retarget.c
  group libs
    ../../Libraries/fs/: fs.lib
    ../../Libraries/driver/: driver.lib
    ./: pitch_shifter.lib
    ../../Libraries/audio/: audio_utility.lib audio_decoder.lib
