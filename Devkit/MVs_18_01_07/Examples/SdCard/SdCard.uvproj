# Keil uVision project SdCard.uvproj, settings and files
target MVs18 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: MVs18
  c flags: Optim=1 OneElfS=1
  c include: ..\..\Libraries\driver\inc;..\..\Libraries\fs\inc
  scatter file: .\SdCard.sct
  link misc: --keep *.o(.mach*.init)  --keep *.o(.shell*.cmd)  --keep *.o(.notify*.init)  --keep *.o(.sched.stub*) --keep *.o(.driver*.isr) --keep *.o(CACHE.4KBMEM)
--diag_suppress=L6314W,L6319W
  group main
    ./: startup.c sdcard.c retarget.c
  group libs
    ../../Libraries/driver/: driver.lib
