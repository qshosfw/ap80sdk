# Keil uVision project UpgradeCheck.uvproj, settings and files
target UpgradeCheck (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: UpgradeCheck +hex
  c flags: Optim=4 OneElfS=1
  c define: INDEPEND_FREERTOS
  c misc: --diag_suppress=A1488W
  c include: .;..\..\Libraries\fs\inc;..\..\Libraries\driver\inc
  scatter file: .\UpgradeCheck.sct
  group fs
    ./fs/: diskio.c filesort.c partition.c presearch.c
  group lib
    ../../Libraries/fs/: fs.lib
    ../../Libraries/driver/: driver.lib
  group src
    ./: retarget.c startup.c upgrade_check.c
