# Keil uVision project BtRfTest.uvproj, settings and files
target BtRfTest (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: BtRfTest
  AfterMake: cmd /C del /Q *.o *.d *.crf  *.dep *.lnp
  c flags: Optim=1 OneElfS=1
  c define: FUNC_DEBUG_EN
  c include: ..\..\Libraries\bluetooth\inc;..\..\Libraries\driver\inc
  scatter file: .\BtRfTest.sct
  link misc: --keep *.o(.mach*.init)  --keep *.o(.shell*.cmd)  --keep *.o(.notify*.init)  --keep *.o(.sched.stub*) --keep *.o(.driver*.isr) --keep *.o(CACHE.4KBMEM) --diag_suppress=L6314W,L6319W
  group libs
    ../../Libraries/driver/: driver.lib
    ./: bt-no-os.lib
  group main
    ./: main.c startup.c task_bt.c bt_device_cfg.c bt_rf_test.c mtk_rf_test_cmd.c retarget.c
