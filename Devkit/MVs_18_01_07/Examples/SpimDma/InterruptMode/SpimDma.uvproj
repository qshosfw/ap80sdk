# Keil uVision project SpimDma.uvproj, settings and files
target SpimDma (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: SpimDma +hex
  AfterMake: fromelf.exe --bin -o "#L.bin" "#L"
  c flags: Optim=1 oTime=1 OneElfS=1
  c define: FUNC_DEBUG_EN FUNC_APP_DEBUG_EN
  c include: ..\..\..\Libraries\driver\inc;..\..\..\src\inc
  scatter file: .\SpimDma.sct
  link misc: --keep *.o(.driver*.isr) --keep *.o(CACHE.4KBMEM)
  group main
    ./: SpimDma.c startup.c retarget.c
  group libs
    ../../../Libraries/driver/: driver.lib
